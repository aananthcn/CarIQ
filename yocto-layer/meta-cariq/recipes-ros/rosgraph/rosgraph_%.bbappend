FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://roslogging.patch"
