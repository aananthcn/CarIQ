SRC_URI:remove = "file://0001-Add-in-a-missing-cstdint-include.-1321-1322.patch"
