FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://001-codec-cpp-macro-arg-fix.patch"

LICENSE = "BSD-3-Clause"
