EXTRA_OECONF += " CONFIG_IFCONFIG=y \
	CONFIG_NC_SERVER=y \
	CONFIG_NETSTAT=y \
	CONFIG_WGET=y \
	CONFIG_TRACEROUTE=y \
"
