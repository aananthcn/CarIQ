DEPENDS += "gtk+3"
PACKAGECONFIG:append = " gtk"