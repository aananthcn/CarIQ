
EXTRA_OECONF += " --enable-x264"
