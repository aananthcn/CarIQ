PV = "4.9.4"
SRC_URI = "https://files.pythonhosted.org/packages/0c/df/733e3a364f4d47b0eb2e8c4253ba1fbed7cc5c0caddc2c64816f8be2db86/lxml-4.9.4.tar.gz"
SRC_URI[sha256sum] = "b1541e50b78e15fa06a2670157a1962ef06591d4c998b998047fff5e3236880e"
