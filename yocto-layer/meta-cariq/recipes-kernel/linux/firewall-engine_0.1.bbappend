EXTERNALSRC := "${THISDIR}/../../../../yocto-shared/ara-api/fw/firewall_engine"
FILESEXTRAPATHS:prepend := "${THISDIR}/../../../../yocto-shared/ara-api/fw/firewall_engine:${THISDIR}/../../../../yocto-shared/ara-api/fw/common/:"
