EXTERNALSRC := "${THISDIR}/../../../../yocto-shared/ara-api/fw/test"
FILESEXTRAPATHS:prepend := "${THISDIR}/../../../../yocto-shared/ara-api/fw/test/:"
