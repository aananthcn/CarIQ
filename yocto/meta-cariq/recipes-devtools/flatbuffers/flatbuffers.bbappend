# Tensoflow-lite expects a lower version
PV = "23.5.26"
SRC_URI = "git://github.com/google/flatbuffers.git;protocol=https;branch=master"
SRCREV = "0100f6a5779831fa7a651e4b67ef389a8752bd9b"
