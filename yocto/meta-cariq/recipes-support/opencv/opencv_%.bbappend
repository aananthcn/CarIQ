LICENSE ??= "Apache-2.0"

PACKAGECONFIG:append = " dnn"

EXTRA_OECMAKE += "-DWITH_FRAMEBUFFER=ON"
EXTRA_OECMAKE += "-DWITH_FRAMEBUFFER_XVFB=ON"
EXTRA_OECMAKE += "-DWITH_OPENVX=ON"
